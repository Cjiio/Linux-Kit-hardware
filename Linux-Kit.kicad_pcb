File: Linux-Kit.kicad_pcb (KiCad board)
At the start: 6 copper layers, 0 parts

Commit message: chore: Update project file names and paths for Linux-Kit
Other:
- board outline added: 63.4 x 52.5 mm
